# Keil uVision project Secure.uvprojx, settings and files
target Secure (6240000::V6.24::ARMCLANG)
  device: M3351KJCAE Nuvoton
  pack: Nuvoton.NuMicroM33_DFP.1.0.2
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x30000000,0x20000) IROM(0x00000000,0x100000) IROM2(0x10000000,0x100000) IROM3(0x0F100000,0x4000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: Secure
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: DEBUG_PORT=UART0_NS
  c include: ..\..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\..\Library\CMSIS\compiler\include;..\..\..\..\..\Library\Device\Nuvoton\M3351\Include;..\..\..\..\..\Library\StdDriver\inc;..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Secure.scf
  link misc: --import-cmse-lib-out ..\..\lib\nsclib.o --datacompressor=off
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M3351/Source/: startup_M3351.c system_M3351.c
  group Library
    ../../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c gpio.c fmc.c
  group User
    ../../: partition_M3351.h
    ../: main.c
